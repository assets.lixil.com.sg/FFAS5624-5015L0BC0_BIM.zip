Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-04-18T09:59:32+07:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_307517 | SINK
Port_307517 | SOURCE

# IfcFlowTerminal: FFAS5624-5015L0BC0_REVIT:Neo Modern Kitchen Faucet(Lead Free), FFAS5624-5015L0BC0_REVIT:Neo Modern Kitchen Faucet(Lead Free):307517
In: Level 1
Type - Material: <Unnamed>, Brass (4)
Type - Pset_DuctConnection - ConnectionType: N/A
Type - Pset_PipeConnection - ConnectionType: N/A
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Neo Modern Kitchen Faucet(Lead Free); sets with these values: 2
